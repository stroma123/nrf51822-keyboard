# Keil uVision project ble_app_hids_keyboard_s110_pca10028.uvprojx, settings and files
target Generic (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD SOFTDEVICE_PRESENT S110 NRF51 BLE_DFU_APP_SUPPORT
  c misc: --gnu --preinclude=config.h
  c include: ..\..\config;..\..\..\sdk;..\..\..\tmk_core\common;..\..\ble\;..\..\keyboard\
  asm define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 BSP_UART_SUPPORT SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 BLE_DFU_APP_SUPPORT
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../ble/: main.c battery_service.c ble_hid_service.c ble_services.c
    ../../keyboard/: keyboard_led.c keymap_plain.c keyboard_matrix.c keyboard_timer.c host_driver.c storage.c keyboard_fn.c keymap_storage.c uart_driver.c xprintf.c
  group nRF_BLE
    ../../../sdk/: ble_advdata.c ble_advertising.c ble_bas.c ble_conn_params.c ble_dis.c ble_hids.c ble_srv_common.c device_manager_peripheral.c bootloader_util.c dfu_app_handler.c ble_dfu.c
  group nRF_Drivers
    ../../../sdk/: app_uart_fifo.c nrf_delay.c nrf_drv_common.c nrf_drv_uart.c pstorage.c nrf_adc.c
  group nRF_Libraries
    ../../../sdk/: app_error.c app_fifo.c app_scheduler.c app_timer.c app_timer_appsh.c app_trace.c nrf_assert.c retarget.c
  group nRF_SoftDevice
    ../../../sdk/: softdevice_handler.c softdevice_handler_appsh.c
  group tmk_core
    ../../../tmk_core/common/: action.c action_layer.c action_macro.c action_tapping.c action_util.c debug.c hook.c host.c keyboard.c matrix.c print.c util.c keymap.c bootmagic.c
target Softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: s110_nrf51_8.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: ..\..\..\config\ble_app_hids_keyboard_s110_pca10028;..\..\..\config;..\..\..\..\..\..\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target BLE4100 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE4100 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD SOFTDEVICE_PRESENT S110 NRF51 BLE_DFU_APP_SUPPORT BLE4100
  c misc: --gnu --preinclude=config.h
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
target BLE60 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: BLE60 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD SOFTDEVICE_PRESENT S110 NRF51 BLE_DFU_APP_SUPPORT BLE60
  c misc: --gnu --preinclude=config.h
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
target BLE400 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: BLE400 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD SOFTDEVICE_PRESENT S110 NRF51 BLE_DFU_APP_SUPPORT BLE400 SWI_DISABLE0
  c misc: --gnu --preinclude=config.h
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x12000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 5.1.1, CMSIS:CORE 4.3.0, Device:Startup 8.2.0
