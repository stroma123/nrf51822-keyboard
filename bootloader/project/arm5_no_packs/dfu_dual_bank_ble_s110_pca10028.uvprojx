# Keil uVision project dfu_dual_bank_ble_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x0003C000,0x3C00) IRAM(0x20002000,0x6000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF51
  c misc: --c99
  c include: ..\..\config;..\..\..\sdk;..\..\..\main\keyboard
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../../: dfu_ble_svc.c main.c dfu_transport_ble.c
  group nRF_BLE
    ../../../sdk/: ble_advdata.c ble_conn_params.c ble_dfu.c ble_srv_common.c
  group nRF_Drivers
    ../../../sdk/: nrf_delay.c pstorage_raw.c
  group nRF_Libraries
    ../../../sdk/: app_error.c app_scheduler.c app_timer.c app_timer_appsh.c bootloader.c bootloader_settings.c bootloader_util.c crc16.c dfu_dual_bank.c dfu_init_template.c hci_mem_pool.c nrf_assert.c
  group nRF_SoftDevice
    ../../../sdk/: softdevice_handler.c softdevice_handler_appsh.c
target BLE4100 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BLE4100 +hex
  c flags: Optim=4 v6Lang=3 v6LangP=3 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 BLE4100
  c misc: --c99
  c include: ..\..\config;..\..\..\sdk;..\..\..\main\keyboard
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
target BLE60 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: BLE60 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 BLE60
  c misc: --c99
  c include: ..\..\config;..\..\..\sdk;..\..\..\main\keyboard
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
target BLE400 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: BLE400 +hex
  c flags: Optim=4 v6Lang=3 v6LangP=3 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_CUSTOM S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 BLE400
  c misc: --c99
  c include: ..\..\config;..\..\..\sdk;..\..\..\main\keyboard
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_CUSTOM S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
